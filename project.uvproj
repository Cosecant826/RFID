# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c define.h Delay.c Delay.h DS1302.c DS1302.h lcd12864.c lcd12864.h MatrixKey.c MatrixKey.h Timer.c Timer.h rc522.c rc522.h HX711.h HX711.c syn6288.c syn6288.h sysEEPROM.c sysEEPROM.h uart.c uart.h
